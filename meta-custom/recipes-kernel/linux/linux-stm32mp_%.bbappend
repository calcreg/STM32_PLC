
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0003-add-can1-dts-solve-hdmi-conflict.patch"


